Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-26T14:43:34+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: 5512BF(2024):5512BF Washbasin faucet, 5512BF(2024):5512BF Washbasin faucet:490543
In: Level 1
Type - Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 178 mm; FaucetNominalHeight: 212 mm; FaucetNominalWidth: 58 mm; HandShowerNominalDepth: 64 mm; HandShowerNominalHeight: 338.2 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 5512BF(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: 2; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 3; VersionDate: 2025/10/01
Type - Green Building Properties - CO2 Emissions (A1-A3): 14.74; CO2 Emissions (A4): 0.41; CO2 Emissions (B7): 2039.4; CO2 Emissions (C2): 0.03; CO2 Emissions (C3): 0.03; CO2 Emissions (C4): 0.11; CO2 Emissions (D): -10.48; EN Standard: EN 817, EN 1113; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6445401; Noise Class: I (ISO 3822); NRF Number: 4200253; RSK Number: 8325251; STF Certificate: EUFI29-22005198-TH; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/5512BF; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.oras.com/EPD/5512BF; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/196172_5512BF_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/5512BF; VVS Number: 703889404
Type - Identity Data - 3D View: https://static.oras.com/3D/5512BF; Catalog Drawing URL: http://static.oras.com/catdrw/5512BF; Category B2B: Health & Care; Dimension Drawing URL: http://static.oras.com/dimdrw/5512BF; FDV Document URL: http://www.oras.com/datasheet/5512BF/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5512BF; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/5512BF; Interactive AR View URL: https://static.oras.com/AR/5512BF; Long Marketing: Oras Medipro washbasin faucet with disinfection wash proof Bidetta shower set. Firm loop-lever offers good usability to all users and situations. Fixed spout and laminar flow. Shower hose 1.5 m, wall bracket, two pairs of quick-release couplings. Special flexible connection pipes with G3/8" nut.; Manufacturer: Oras; Market: Denmark;Estonia;Finland;International;Lithuania;Latvia;Norway;Poland;Sweden; Mobile Product Information URL: http://mpi.oras.com/5512BF; Model: 5512BF Washbasin faucet; Name_en: 5512BF Washbasin faucet; OmniClass Number: 23.45.55.00; Product Code: 5512BF; Product Family: Oras Medipro Protec; Product Image URL: http://static.oras.com/image/5512BF; Product URL: http://static.oras.com/5512BF; Spare-Part Information URL: http://static.oras.com/sp/5512BF; Technical DataSheet URL: http://www.oras.com/datasheet/5512BF/en; Type Name: 5512BF Washbasin faucet; Usage Group: Hospitals;NurseringHomes; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;Surfaces in contact with drinking water contain less than 0.3% lead;Waterways without nickel coating;Disinfection proof (max. +95°C);Thermal disinfection proof for short durations;Rapid installation system; Aerator: Laminar stream; Backflow Prevention EN1717: HC; Connection: Flexible inlet pipes;Special coating for hygienic premises; Connection Size: G3/8; Excluded Items: Without pop-up waste;Without draw-rod opening; Flow Rate At 300kPa: 0.11 m3/s; Hand Shower: Bidetta hand shower;Quick release coupling; Installation Type: Deck mounted; Lever Handle: Loop shape;Hot/Cold symbols;Single operating lever/handle;Long shape; Max. Hot Water Supply: 70 C; Mechanical Parts: ø 48 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Number of Shower Sprays: 1Spray; Shower Parts: Hand shower;Shower holder;Shower hose (1500 mm); Shower Spray Number: 1 spray function; Spout Projection: 120 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5512BF(2024); Features: Single-lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5512BF; Name: 5512BF Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:58x178x212 mm / Hand shower: 46x64x338 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 5512BF; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 5512BF Washbasin faucet; Category: Plumbing Fixtures
Material: <Unnamed>, Brass
Pset_DistributionFlowElementCommon - Reference: 5512BF Washbasin faucet; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; HandshowerVisibility: yes; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.101645 m2; Volume: 0.00319327 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5512BF(2024); Family and Type: 5512BF(2024): 5512BF Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5512BF Washbasin faucet; Type Id: 490527; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
